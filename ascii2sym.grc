options:
  parameters:
    author: Ben Cometto
    category: '[Pulse Amplitude Modulation]'
    generate_options: hb_qt_gui
    id: ascii2sym
    output_language: python
    title: ASCII to Float Symbols Hier Block
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: M
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: bits_per_sym
  id: parameter
  parameters:
    value: '1'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '(127 if is_7_bit_ascii==1 else 255) '
    type: byte
  states: {}
- name: blocks_add_const_vxx_1
  id: blocks_add_const_vxx
  parameters:
    const: '-pol*(M-1) if pol ==1 else 0  '
    type: float
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '0.5 if pol == 1 else 1 '
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[x for x in range(2**8)] if invert_bits == 0 else [x for x in range(2**8-1,-1,-1)] '
  states: {}
- name: invert_bits
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: is_7_bit_ascii
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: pol
  id: parameter
  parameters:
    value: '0'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', digital_map_bb_0, '0']
- [blocks_add_const_vxx_1, '0', pad_sink_0, '0']
- [blocks_char_to_float_0, '0', blocks_add_const_vxx_1, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_char_to_float_0, '0']
- [digital_map_bb_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [pad_source_0, '0', blocks_add_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
