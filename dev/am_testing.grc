options:
  parameters:
    author: Ben Cometto
    generate_options: qt_gui
    id: am_testing
    output_language: python
    title: AM Testing
  states: {}

blocks:
- name: ac
  id: variable
  parameters:
    value: '1'
  states: {}
- name: am
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: fc
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: filter_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: fc
    low_cutoff_freq: int(0.1*fc)
    samp_rate: samp_rate
    type: band_pass
    width: int(0.1*fc)
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '64000'
  states: {}
- name: am_demod_0
  id: am_demod
  parameters:
    fc: fc
    filter_taps: filter_taps
    gain: '5'
    samp_rate: samp_rate
  states: {}
- name: am_mod_0
  id: am_mod
  parameters:
    ac: ac
    am: am
    fc: fc
    samp_rate: samp_rate
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.05'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '0.03'
    freq: '2000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: round((len(filter_taps)-1)/2)
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    label1: '"Signal"'
    name: '"Signal"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    label1: '"Signal"'
    name: '"Mod"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    label1: '"Signal"'
    name: '"Demod"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Demod"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"Mod"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Signal
    label2: Demod
    name: '"Signals"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [am_demod_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [am_demod_0, '0', qtgui_time_sink_x_0, '0']
- [am_demod_0, '0', qtgui_time_sink_x_2, '1']
- [am_mod_0, '0', am_demod_0, '0']
- [am_mod_0, '0', qtgui_freq_sink_x_0_0, '0']
- [am_mod_0, '0', qtgui_time_sink_x_1, '0']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '0']
- [analog_sig_source_x_1, '0', blocks_add_xx_0, '1']
- [blocks_add_xx_0, '0', am_mod_0, '0']
- [blocks_add_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_delay_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_throttle2_0, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
