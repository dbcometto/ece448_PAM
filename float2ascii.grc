options:
  parameters:
    author: Ben Cometto
    category: '[Pulse Amplitude Modulation]'
    generate_options: hb_qt_gui
    id: float2ascii
    output_language: python
    title: Float Symbols to ASCII Hier Block
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: 2**bits_per_sym
  states: {}
- name: endianness
  id: variable
  parameters:
    value: gr.endianness_t.GR_LSB_FIRST if is_LSB==1 else gr.endianness_t.GR_MSB_FIRST
  states: {}
- name: bits_per_sym
  id: parameter
  parameters:
    value: '1'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '(M-1) if is_polar ==1 else 0  '
    type: float
  states: {}
- name: blocks_and_const_xx_0_0
  id: blocks_and_const_xx
  parameters:
    const: '(127 if is_7_bit_ascii==1 else 255) '
    type: byte
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: symbol_delay
    type: byte
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '0.5 if is_polar == 1 else 1 '
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: float
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: bits_per_sym
    endianness: endianness
    type: byte
  states: {}
- name: digital_map_bb_0_0
  id: digital_map_bb
  parameters:
    map: '[x for x in range(2**8)] if invert_bits==0 else [x for x in range(2**8-1,-1,-1)]'
  states: {}
- name: gain
  id: parameter
  parameters:
    value: '1'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: invert_bits
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: is_7_bit_ascii
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: is_LSB
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: is_polar
  id: parameter
  parameters:
    value: '1'
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    hide: part
    value: '32000'
  states: {}
- name: symbol_delay
  id: parameter
  parameters:
    value: '0'
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_float_to_char_0, '0']
- [blocks_and_const_xx_0_0, '0', pad_sink_1, '0']
- [blocks_delay_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_float_to_char_0, '0', blocks_delay_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', digital_map_bb_0_0, '0']
- [digital_map_bb_0_0, '0', blocks_and_const_xx_0_0, '0']
- [pad_source_1, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
