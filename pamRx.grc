options:
  parameters:
    author: Ben Cometto
    category: '[Pulse Amplitude Modulation]'
    generate_options: hb_qt_gui
    id: pamRx
    output_language: python
    title: PAM Receiver Hier Block
  states: {}

blocks:
- name: pt_taps
  id: variable
  parameters:
    value: pf.pamhRt(samples_per_symbol,pulse_type,[tail_length,alpha])
  states: {}
- name: alpha
  id: parameter
  parameters:
    type: eng_float
    value: '0.2'
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sample_delay
    type: float
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: pt_taps
    type: fff
  states: {}
- name: fir_filter_xxx_1
  id: fir_filter_xxx
  parameters:
    decim: samples_per_symbol
    taps: '1'
    type: fff
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pam_functions as pf
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: samples_per_symbol
    taps: '1'
    type: fff
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: samp_out
    type: float
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: mf_out
    type: float
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: float
  states: {}
- name: pulse_type
  id: parameter
  parameters:
    type: str
    value: rect
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    hide: part
    type: intx
    value: '32000'
  states: {}
- name: sample_delay
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: samples_per_symbol
  id: parameter
  parameters:
    type: intx
    value: '10'
  states: {}
- name: tail_length
  id: parameter
  parameters:
    type: eng_float
    value: '5'
  states: {}

connections:
- [blocks_delay_0, '0', fir_filter_xxx_1, '0']
- [blocks_delay_0, '0', pad_sink_1, '0']
- [fir_filter_xxx_0, '0', blocks_delay_0, '0']
- [fir_filter_xxx_1, '0', interp_fir_filter_xxx_0, '0']
- [fir_filter_xxx_1, '0', pad_sink_2, '0']
- [interp_fir_filter_xxx_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
