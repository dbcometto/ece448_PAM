options:
  parameters:
    author: Ben Cometto
    generate_options: qt_gui
    id: PAM_main
    output_language: python
    title: PAM Main File
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: bits_per_sym
  id: variable
  parameters:
    value: '1'
  states: {}
- name: invert_bits
  id: variable
  parameters:
    value: '0'
  states: {}
- name: is_7_bit_ascii
  id: variable
  parameters:
    value: '0'
  states: {}
- name: is_LSB
  id: variable
  parameters:
    value: '0'
  states: {}
- name: is_polar
  id: variable
  parameters:
    value: '1'
  states: {}
- name: msg_start
  id: variable_tag_object
  parameters:
    key: pmt.intern("Start")
    offset: '0'
    src: pmt.intern("src")
    value: pmt.intern("Start")
  states: {}
- name: pulse_type
  id: variable
  parameters:
    value: '"rect"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: '10'
  states: {}
- name: tail_length
  id: variable
  parameters:
    value: '3'
  states: {}
- name: ascii2float_0
  id: ascii2float
  parameters:
    bits_per_sym: bits_per_sym
    invert_bits: invert_bits
    is_7_bit_ascii: is_7_bit_ascii
    is_LSB: is_LSB
    is_polar: is_polar
    samp_rate: samp_rate
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\ece448_PAM\test_output.bin
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[msg_start]'
    type: byte
    vector: (90,111)
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: samples_per_symbol
    taps: '1'
    type: fff
  states: {}
- name: float2ascii_0
  id: float2ascii
  parameters:
    bits_per_sym: bits_per_sym
    gain: '1'
    invert_bits: invert_bits
    is_7_bit_ascii: is_7_bit_ascii
    is_LSB: is_LSB
    is_polar: is_polar
    samp_rate: samp_rate
    symbol_delay: '0'
  states: {}
- name: pamTx_0
  id: pamTx
  parameters:
    alpha: alpha
    pulse_type: pulse_type
    samp_rate: samp_rate
    samples_per_symbol: samples_per_symbol
    tail_length: tail_length
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    name: '"Float Symbols"'
    size: '20'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"Start"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    name: '"Tx"'
    size: '200'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"Start"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    name: '"Rx Float Symbols"'
    size: '20'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"Start"'
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: data_tx
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: data_rx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: data_rx
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: data_tx
  states: {}

connections:
- [ascii2float_0, '0', pamTx_0, '0']
- [ascii2float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_0, '0', virtual_sink_0_0, '0']
- [blocks_throttle2_0, '0', ascii2float_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle2_0, '0']
- [fir_filter_xxx_0, '0', float2ascii_0, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_0_1, '0']
- [float2ascii_0, '0', blocks_file_sink_0, '0']
- [pamTx_0, '0', qtgui_time_sink_x_0_0, '0']
- [pamTx_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', fir_filter_xxx_0, '0']
- [virtual_source_1, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
