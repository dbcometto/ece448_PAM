options:
  parameters:
    author: Ben Cometto
    generate_options: qt_gui
    id: PAM_main
    output_language: python
    title: PAM Main File
  states: {}

blocks:
- name: ac
  id: variable
  parameters:
    value: '1'
  states: {}
- name: alpha
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '5'
    value: '0.5'
    widget: eng
  states: {}
- name: am
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: baud_rate
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '50000'
    value: '25600'
  states: {}
- name: bits_per_sym
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '1'
    step: '1'
    stop: '100'
    value: '1'
    widget: eng
  states: {}
- name: channel_delay
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: fc
  id: variable
  parameters:
    value: '80000'
  states: {}
- name: filter_delay
  id: variable
  parameters:
    value: round((len(filter_taps)-1)/2)
  states: {}
- name: filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: fc/2
    gain: '1.0'
    samp_rate: samp_rate
    width: round(0.1*fc)
    win: window.WIN_HAMMING
  states: {}
- name: invert_bits
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: is_7_bit_ascii
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: is_LSB
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: is_polar
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: msg_start
  id: variable_tag_object
  parameters:
    key: pmt.intern("Start")
    offset: '0'
    src: pmt.intern("src")
    value: pmt.intern("Start")
  states: {}
- name: noise_amplitude
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '5'
    value: '0'
    widget: eng_slider
  states: {}
- name: pulse_type
  id: variable_qtgui_chooser
  parameters:
    num_opts: '4'
    option0: '"rect"'
    option1: '"rcf"'
    option2: '"sinc"'
    option3: '"ramp"'
    orient: Qt.QHBoxLayout
    type: string
    value: '"rcf"'
    widget: radio_buttons
  states: {}
- name: recv_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '50'
    value: '15'
    widget: dial
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: sample_delay
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: samples_per_symbol*8-1
    value: '46'
    widget: eng_slider
  states: {}
- name: samples_per_symbol
  id: variable
  parameters:
    value: round(samp_rate/baud_rate)
  states: {}
- name: symbol_delay
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '0'
  states: {}
- name: tail_length
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '0.1'
    stop: '10'
    value: '3'
    widget: eng
  states: {}
- name: am_demod_0
  id: am_demod
  parameters:
    fc: fc
    filter_taps: filter_taps
    gain: recv_gain
    samp_rate: samp_rate
  states: {state: disabled}
- name: am_mod_0
  id: am_mod
  parameters:
    ac: ac
    am: am
    fc: fc
    samp_rate: samp_rate
  states: {state: disabled}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: noise_amplitude
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '42'
    type: float
  states: {}
- name: ascii2float_0
  id: ascii2float
  parameters:
    bits_per_sym: bits_per_sym
    invert_bits: invert_bits
    is_7_bit_ascii: is_7_bit_ascii
    is_LSB: is_LSB
    is_polar: is_polar
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: channel_delay
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: sample_delay
    type: float
  states: {}
- name: blocks_delay_1_0
  id: blocks_delay
  parameters:
    delay: sample_delay
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\workspace\ece448_PAM\test_output.bin
    type: byte
  states: {state: disabled}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: '1000'
    max_iter: '4000'
    scale: 1/1000
    type: float
  states: {}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[msg_start]'
    type: byte
    vector: (69,67,69,52,52,56,32)
  states: {}
- name: float2ascii_0
  id: float2ascii
  parameters:
    bits_per_sym: bits_per_sym
    gain: '1'
    invert_bits: invert_bits
    is_7_bit_ascii: is_7_bit_ascii
    is_LSB: is_LSB
    is_polar: is_polar
    samp_rate: samp_rate
    symbol_delay: symbol_delay
  states: {}
- name: note_0
  id: note
  parameters:
    note: sample_delay = 11-(channel_delay mod 10)
  states: {}
- name: note_1
  id: note
  parameters:
    note: 'rect: sample 1, symbol 7'
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: 'rcf: sample 6, symbol 4'
  states: {}
- name: pamRx_0
  id: pamRx
  parameters:
    alpha: '0.2'
    pulse_type: rect
    samp_rate: samp_rate
    sample_delay: sample_delay
    samples_per_symbol: samples_per_symbol
    tail_length: tail_length
  states: {}
- name: pamTx_0
  id: pamTx
  parameters:
    alpha: alpha
    pulse_type: pulse_type
    samp_rate: samp_rate
    samples_per_symbol: samples_per_symbol
    tail_length: tail_length
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '16384'
    name: '"Tx in Freq"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"red"'
    fc: '0'
    fftsize: '16384'
    name: '"Rx in Freq"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    label1: Tx Float Sym
    label2: Rx Float Sym
    name: '"Float Symbols"'
    nconnections: '2'
    size: '80'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"Start"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    label1: Tx Data
    label2: Rx Data
    name: '"Tx/Rx"'
    nconnections: '2'
    size: '800'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"Start"'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    label1: Sampler
    label2: MF
    name: '"Rx Output"'
    nconnections: '2'
    size: '800'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"Start"'
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    name: '"Received Signal"'
    size: samples_per_symbol*20
    srate: samp_rate
    type: float
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: data_tx
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: data_rx
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: float_sym_tx
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: float_sym_rx
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: rx_samp
  states: {}
- name: virtual_sink_2_1
  id: virtual_sink
  parameters:
    stream_id: rx_mf
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: data_am
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: data_rx
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: data_tx
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: float_sym_tx
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: float_sym_rx
  states: {}
- name: virtual_source_4
  id: virtual_source
  parameters:
    stream_id: data_tx
  states: {}
- name: virtual_source_4_0
  id: virtual_source
  parameters:
    stream_id: rx_samp
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: data_rx
  states: {}
- name: virtual_source_5_0
  id: virtual_source
  parameters:
    stream_id: rx_mf
  states: {}
- name: virtual_source_5_1
  id: virtual_source
  parameters:
    stream_id: data_rx
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: data_am
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://localhost:4444
    timeout: '1'
    type: byte
  states: {}

connections:
- [am_demod_0, '0', virtual_sink_0_0, '0']
- [am_mod_0, '0', virtual_sink_3, '0']
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [ascii2float_0, '0', pamTx_0, '0']
- [ascii2float_0, '0', virtual_sink_1, '0']
- [blocks_add_xx_0, '0', am_demod_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0_0, '0']
- [blocks_delay_0, '0', blocks_add_xx_0, '0']
- [blocks_delay_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_1_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_moving_average_xx_1, '0', blocks_sub_xx_0, '1']
- [blocks_sub_xx_0, '0', pamRx_0, '0']
- [blocks_throttle2_0, '0', ascii2float_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle2_0, '0']
- [float2ascii_0, '0', blocks_file_sink_0, '0']
- [float2ascii_0, '0', zeromq_push_sink_0, '0']
- [pamRx_0, '0', virtual_sink_2_0, '0']
- [pamRx_0, '1', virtual_sink_2_1, '0']
- [pamRx_0, '2', float2ascii_0, '0']
- [pamRx_0, '2', virtual_sink_2, '0']
- [pamTx_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', blocks_moving_average_xx_1, '0']
- [virtual_source_0, '0', blocks_sub_xx_0, '0']
- [virtual_source_1, '0', am_mod_0, '0']
- [virtual_source_1, '0', virtual_sink_3, '0']
- [virtual_source_2, '0', blocks_delay_1, '0']
- [virtual_source_3, '0', qtgui_time_sink_x_0, '1']
- [virtual_source_4, '0', blocks_delay_1_0, '0']
- [virtual_source_4, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_4_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [virtual_source_5, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_5, '0', qtgui_time_sink_x_0_0, '1']
- [virtual_source_5_0, '0', qtgui_time_sink_x_0_0_0, '1']
- [virtual_source_5_1, '0', qtgui_time_sink_x_1, '0']
- [virtual_source_6, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.10.0
