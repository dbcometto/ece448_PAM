options:
  parameters:
    author: Ben Cometto
    generate_options: qt_gui
    id: PAM_main
    output_language: python
    title: PAM Main File
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: ascii2sym_0
  id: ascii2sym
  parameters:
    M: '0'
    bits_per_sym: '1'
    invert_bits: '0'
    is_7_bit_ascii: '0'
    pol: '0'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (90, 111)
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [ascii2sym_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', ascii2sym_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
