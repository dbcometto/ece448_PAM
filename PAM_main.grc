options:
  parameters:
    author: Ben Cometto
    generate_options: qt_gui
    id: PAM_main
    output_language: python
    title: PAM Main File
  states: {}

blocks:
- name: bits_per_sym
  id: variable
  parameters:
    value: '1'
  states: {}
- name: invert_bits
  id: variable
  parameters:
    value: '0'
  states: {}
- name: is_7_bit_ascii
  id: variable
  parameters:
    value: '0'
  states: {}
- name: is_LSB
  id: variable
  parameters:
    value: '0'
  states: {}
- name: is_polar
  id: variable
  parameters:
    value: '0'
  states: {}
- name: msg_start
  id: variable_tag_object
  parameters:
    key: pmt.intern("Start")
    offset: '0'
    src: pmt.intern("src")
    value: pmt.intern("Start")
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: ascii2float_0
  id: ascii2float
  parameters:
    bits_per_sym: bits_per_sym
    invert_bits: invert_bits
    is_7_bit_ascii: is_7_bit_ascii
    is_LSB: is_LSB
    is_polar: is_polar
    samp_rate: samp_rate
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\ece448_PAM\test_output.bin
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    tags: '[msg_start]'
    type: byte
    vector: (90,111)
  states: {}
- name: float2ascii_0
  id: float2ascii
  parameters:
    bits_per_sym: bits_per_sym
    gain: '1'
    invert_bits: invert_bits
    is_7_bit_ascii: is_7_bit_ascii
    is_LSB: is_LSB
    is_polar: is_polar
    samp_rate: samp_rate
    symbol_delay: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    size: '20'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"Start"'
    type: float
  states: {}

connections:
- [ascii2float_0, '0', blocks_throttle2_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_throttle2_0, '0', float2ascii_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_0, '0', blocks_throttle2_0, '0']
- [blocks_vector_source_x_0, '0', ascii2float_0, '0']
- [blocks_vector_source_x_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [float2ascii_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
